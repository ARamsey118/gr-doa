options:
  parameters:
    generate_options: no_gui
    id: run_calib_lin_array_simulation
    output_language: python
    run_options: run
  states: {}

blocks:
- name: amv0
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv0_true)
  states: {}
- name: amv0_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(pilot_theta0))
  states: {}
- name: ant_coeffs
  id: variable
  parameters:
    value: input_variables.AntGains*numpy.exp(1j*input_variables.AntPhases)
  states: {}
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(0.5, numpy.arange(input_variables.NumArrayElements/2, -input_variables.NumArrayElements/2, -1) if (input_variables.NumArrayElements%2==1) else numpy.arange(input_variables.NumArrayElements/2-0.5, -input_variables.NumArrayElements/2-0.5, -1))
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: array_manifold_matrix
  id: variable
  parameters:
    value: numpy.array([amv0]).transpose()
  states: {}
- name: pilot_theta0
  id: variable
  parameters:
    value: numpy.pi*input_variables.PilotAngleDegrees/180
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: input_variables.ToneFreq2
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: input_variables.NumArrayElements
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: array_manifold_matrix
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: input_variables.SampleRate
    type: complex
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: '1'
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_calibrate_lin_array_0
  id: doa_calibrate_lin_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: input_variables.NumArrayElements
    pilot_angle: input_variables.PilotAngleDegrees
  states: {}
- name: doa_save_antenna_calib_0
  id: doa_save_antenna_calib
  parameters:
    config_filename: antenna_calibration_file_name
    num_inputs: input_variables.NumArrayElements
    samples_to_average: input_variables.Samples2Avg
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: input_variables
  id: epy_module
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    source_code: |
      # Comment here
      import numpy
      SampleRate = 3200000
      ToneFreq1 =     10000
      PilotAngleDegrees =      30.0
      DirectoryConfigFiles =      "/tmp"
      AntennaCalibration =      "calibration_lin_array_simulated.cfg"
      Samples2Avg =      2**11
      ToneFreq2 =     20000
      NormSpacing =     0.5
      NumArrayElements =     4
      PSpectrumLength =     2**10
      SnapshotSize =     2**11
      OverlapSize =     2**9
      AntGains =     numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929])
      AntPhases =     numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])
  states: {}

connections:
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_complex_to_magphase_0, '0', doa_save_antenna_calib_0, '0']
- [blocks_complex_to_magphase_0, '1', doa_save_antenna_calib_0, '1']
- [blocks_multiply_matrix_xx_0, '0', doa_autocorrelate_0, '0']
- [blocks_multiply_matrix_xx_0, '1', doa_autocorrelate_0, '1']
- [blocks_multiply_matrix_xx_0, '2', doa_autocorrelate_0, '2']
- [blocks_multiply_matrix_xx_0, '3', doa_autocorrelate_0, '3']
- [blocks_throttle_0_0, '0', blocks_multiply_matrix_xx_0, '0']
- [doa_autocorrelate_0, '0', doa_calibrate_lin_array_0, '0']
- [doa_calibrate_lin_array_0, '0', blocks_complex_to_magphase_0, '0']

metadata:
  file_format: 1
