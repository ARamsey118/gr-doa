options:
  parameters:
    generate_options: qt_gui
    id: run_MUSIC_calib_lin_array_X310_TwinRX
    output_language: python
  states: {}

blocks:
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: bus_range
  id: variable
  parameters:
    value: '[list(range(0,input_variables.NumArrayElements)),list(range(input_variables.NumArrayElements,input_variables.NumArrayElements*2))]'
  states: {state: disabled}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: input_variables.NumTargets
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: input_variables.NumTargets
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    num_inputs: '4'
    type: complex
  states: {bus_sink: true}
- name: doa_MUSIC_lin_array_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_MUSIC_lin_array_0_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_antenna_correction_0_0
  id: doa_antenna_correction
  parameters:
    config_filename: antenna_calibration_file_name + "horz" + input_variables.ConfigFileExt
    num_inputs: input_variables.NumArrayElements
  states: {bus_sink: true, bus_source: true}
- name: doa_antenna_correction_0_0_0
  id: doa_antenna_correction
  parameters:
    config_filename: antenna_calibration_file_name + "vert" + input_variables.ConfigFileExt
    num_inputs: input_variables.NumArrayElements
  states: {bus_sink: true, bus_source: true}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: '1'
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {bus_sink: true}
- name: doa_autocorrelate_0_0
  id: doa_autocorrelate
  parameters:
    avg_method: '1'
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {bus_sink: true}
- name: doa_compass
  id: doa_qt_compass
  parameters:
    arc_bias: '0'
    gui_hint: tab@1
    max_val: '180'
    min_val: '0'
    name: '""'
    step: '10'
    update_time: '0.05'
  states: {state: disabled}
- name: doa_compass_0
  id: doa_qt_compass
  parameters:
    arc_bias: '0'
    gui_hint: tab@1
    max_val: '180'
    min_val: '0'
    name: '""'
    step: '10'
    update_time: '0.05'
  states: {state: disabled}
- name: doa_find_local_max_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: doa_find_local_max_0_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: doa_phase_correct_hier_1
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name + "vert" + input_variables.ConfigFileExt
    num_ports: input_variables.NumArrayElements
  states: {bus_sink: true, bus_source: true}
- name: doa_phase_correct_hier_1_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name + "horz" + input_variables.ConfigFileExt
    num_ports: input_variables.NumArrayElements
  states: {bus_sink: true, bus_source: true}
- name: doa_tworx_usrp_source_0
  id: doa_tworx_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    antenna: Toggle
    bus_structure_source: '[[0, 1, 2, 3],[4,5,6,7,]]'
    center_freq: input_variables.CenterFreq
    gain: input_variables.Gain
    num_samps: input_variables.SnapshotSize * 4
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {bus_source: true}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: input_variables
  id: epy_module
  parameters:
    comment: |-
      input_variables:
      Contains all the user-defined variables.
    source_code: |
      # this module will be imported into your flowgraph
      import os
      ToneFreq = 10000
      SampleRate = 100000
      CenterFreq = 2450000000
      RxAddr = "addr0=192.168.20.3, addr1=192.168.110.2"
      TxAddr = "addr=192.168.20.3"
      Gain = 60
      NumArrayElements = 4
      NormSpacing = 0.5
      PilotAngle = 45
      SnapshotSize = 2**11
      Samples2FindMax = 2**11
      Samples2Avg = 2**11
      OverlapSize = 2**9
      SkipAhead = 2**13
      NumTargets = 1
      PSpectrumLength = 2**10
      home = os.path.expanduser("~")
      DirectoryConfigFiles = os.path.join(home, "devel/localization_fulbright/config/")
      ConfigFileExt = ".cfg"
      RelativePhaseOffsets = "measure_X310_TwinRX_relative_phase_offsets_245_"
      CorrectedPhaseOffsets = "measure_X310_TwinRX_corrected_phase_offsets_245_"
      AntennaCalibration = "calibration_lin_array_245_"
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: '180'
    min: '0'
    name: '"vert"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    name: '"horz"'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    showports: 'True'
    update_time: '0.05'
    vlen: input_variables.PSpectrumLength
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/input_variables.PSpectrumLength
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    showports: 'True'
    update_time: '0.05'
    vlen: input_variables.PSpectrumLength
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/input_variables.PSpectrumLength
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {state: disabled}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Pseudo-Spectrum
    label1: Angle of Arrival (MUSIC)
    num_tabs: '2'
  states: {}

connections:
- [doa_MUSIC_lin_array_0, '0', doa_find_local_max_0, '0']
- [doa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [doa_MUSIC_lin_array_0_0, '0', doa_find_local_max_0_0, '0']
- [doa_MUSIC_lin_array_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [doa_antenna_correction_0_0, '4', doa_autocorrelate_0_0, '4']
- [doa_antenna_correction_0_0_0, '4', doa_autocorrelate_0, '4']
- [doa_autocorrelate_0, '0', doa_MUSIC_lin_array_0, '0']
- [doa_autocorrelate_0_0, '0', doa_MUSIC_lin_array_0_0, '0']
- [doa_find_local_max_0, '0', blocks_null_sink_0, '0']
- [doa_find_local_max_0, '1', doa_compass, '0']
- [doa_find_local_max_0, '1', qtgui_number_sink_0, '0']
- [doa_find_local_max_0_0, '0', blocks_null_sink_0_0, '0']
- [doa_find_local_max_0_0, '1', doa_compass_0, '0']
- [doa_find_local_max_0_0, '1', qtgui_number_sink_0_0, '0']
- [doa_phase_correct_hier_1, '4', doa_antenna_correction_0_0_0, '4']
- [doa_phase_correct_hier_1_0, '4', doa_antenna_correction_0_0, '4']
- [doa_tworx_usrp_source_0, '8', doa_phase_correct_hier_1, '4']
- [doa_tworx_usrp_source_0, '9', blocks_tag_debug_0, '4']
- [doa_tworx_usrp_source_0, '9', doa_phase_correct_hier_1_0, '4']

metadata:
  file_format: 1
