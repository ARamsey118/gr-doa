options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: view_X310_TwinRX_op_with_corrected_phase_offsets
    output_language: python
  states: {}

blocks:
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: doa_phase_correct_hier_1
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_twinrx_usrp_source_0
  id: doa_twinrx_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    gain: input_variables.Gain
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {state: disabled}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}
- name: input_variables
  id: epy_module
  parameters:
    comment: |-
      input_variables:
      Contains all the user-defined variables.
    source_code: |
      # this module will be imported into your flowgraph
      import os
      ToneFreq = 10000
      SampleRate = 1000000
      CenterFreq = 2450000000
      RxAddr = "addr=192.168.20.3"
      TxAddr = "addr=192.168.20.3"
      Gain = 60
      NumArrayElements = 4
      NormSpacing = 0.5
      PilotAngle = 45
      SnapshotSize = 2**11
      Samples2FindMax = 2**11
      Samples2Avg = 2**11
      OverlapSize = 2**9
      SkipAhead = 2**13
      NumTargets = 1
      PSpectrumLength = 2**10
      home = os.path.expanduser("~")
      DirectoryConfigFiles = os.path.join(home, "devel/localization_fulbright/config/")
      RelativePhaseOffsets = "measure_X310_TwinRX_relative_phase_offsets_245.cfg"
      CorrectedPhaseOffsets = "measure_X310_TwinRX_corrected_phase_offsets_245.cfg"
      AntennaCalibration = "calibration_lin_array_245.cfg"
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    label1: 'Channel #0: Real'
    label10: ''
    label2: 'Channel #0: Imag'
    label3: 'Channel #1: Real'
    label4: 'Channel #1: Imag'
    label5: 'Channel #2: Real'
    label6: 'Channel #2: Imag'
    label7: 'Channel #3: Real'
    label8: 'Channel #3: Imag'
    label9: ''
    nconnections: input_variables.NumArrayElements
    size: '256'
    srate: input_variables.SampleRate
    type: complex
    update_time: '0.5'
  states: {}

connections:
- [analog_sig_source_x_0, '0', doa_phase_correct_hier_1, '0']
- [analog_sig_source_x_0, '0', doa_phase_correct_hier_1, '1']
- [analog_sig_source_x_0, '0', doa_phase_correct_hier_1, '2']
- [analog_sig_source_x_0, '0', doa_phase_correct_hier_1, '3']
- [doa_phase_correct_hier_1, '0', qtgui_time_sink_x_0, '0']
- [doa_phase_correct_hier_1, '1', qtgui_time_sink_x_0, '1']
- [doa_phase_correct_hier_1, '2', qtgui_time_sink_x_0, '2']
- [doa_phase_correct_hier_1, '3', qtgui_time_sink_x_0, '3']
- [doa_twinrx_usrp_source_0, '0', doa_phase_correct_hier_1, '0']
- [doa_twinrx_usrp_source_0, '1', doa_phase_correct_hier_1, '1']
- [doa_twinrx_usrp_source_0, '2', doa_phase_correct_hier_1, '2']
- [doa_twinrx_usrp_source_0, '3', doa_phase_correct_hier_1, '3']

metadata:
  file_format: 1
