options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: view_X310_TwinRX_op_with_corrected_phase_offsets
    output_language: python
  states: {}

blocks:
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)+ vert_horz + input_variables.ConfigFileExt
  states: {}
- name: taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 1.2e6
    low_cutoff_freq: 0.8e6
    samp_rate: input_variables.SampleRate
    type: complex_band_pass
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: vert_horz
  id: variable
  parameters:
    value: '"horz"'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: doa_phase_correct_hier_1
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {bus_sink: true}
- name: doa_tworx_usrp_source_0
  id: doa_tworx_usrp_source
  parameters:
    addresses: '"addr0=192.168.20.3, addr1=192.168.110.2"'
    antenna: TX/RX
    bus_structure_source: '[[0,1,2,3,],]'
    center_freq: input_variables.CenterFreq
    gain: input_variables.Gain
    num_samps: '1000'
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {bus_source: true}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: ccc
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}
- name: input_variables
  id: epy_module
  parameters:
    comment: |-
      input_variables:
      Contains all the user-defined variables.
    source_code: |-
      # this module will be imported into your flowgraph
      import os
      ToneFreq = 1e6
      SampleRate = 10e6
      CenterFreq = 2450000000
      RxAddr = "addr=192.168.20.3"
      TxAddr = "addr=192.168.20.3"
      Gain = 60
      NumArrayElements = 4
      NormSpacing = 0.5
      PilotAngle = 45
      SnapshotSize = 2**11
      Samples2FindMax = 2**11
      Samples2Avg = 2**11
      OverlapSize = 2**9
      SkipAhead = 2**13
      NumTargets = 1
      PSpectrumLength = 2**10
      home = os.path.expanduser("~")
      DirectoryConfigFiles = os.path.join(home, "devel/localization_fulbright/config/")
      ConfigFileExt = ".cfg"
      RelativePhaseOffsets = f"measure_X310_TwinRX_relative_phase_offsets_{CenterFreq:.2e}_{SampleRate:.2e}_"
      CorrectedPhaseOffsets = f"measure_X310_TwinRX_corrected_phase_offsets_{CenterFreq:.2e}_{SampleRate:.2e}_"
      AntennaCalibration = f"calibration_lin_array_{CenterFreq:.2e}_{SampleRate:.2e}_" 
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    label1: 'Channel #0: Real'
    label2: 'Channel #0: Imag'
    label3: 'Channel #1: Real'
    label4: 'Channel #1: Imag'
    nconnections: '4'
    size: '256'
    srate: input_variables.SampleRate
    type: float
    update_time: '0.5'
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_real_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [doa_phase_correct_hier_1, '0', fir_filter_xxx_0, '0']
- [doa_phase_correct_hier_1, '0', qtgui_freq_sink_x_0, '0']
- [doa_phase_correct_hier_1, '1', fir_filter_xxx_0_0, '0']
- [doa_phase_correct_hier_1, '2', fir_filter_xxx_0_0_0, '0']
- [doa_phase_correct_hier_1, '3', fir_filter_xxx_0_0_0_0, '0']
- [doa_tworx_usrp_source_0, '4', doa_phase_correct_hier_1, '4']
- [fir_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_real_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [fir_filter_xxx_0_0_0_0, '0', blocks_complex_to_real_0_0_0_0, '0']

metadata:
  file_format: 1
