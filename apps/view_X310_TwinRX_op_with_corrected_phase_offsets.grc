options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: view_X310_TwinRX_op_with_corrected_phase_offsets
    output_language: python
  states: {}

blocks:
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)+ vert_horz + input_variables.ConfigFileExt
  states: {}
- name: vert_horz
  id: variable
  parameters:
    value: '"horz"'
  states: {}
- name: doa_phase_correct_hier_1
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {bus_sink: true, bus_source: true}
- name: doa_tworx_usrp_source_0
  id: doa_tworx_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    antenna: TX/RX
    bus_structure_source: ''
    center_freq: input_variables.CenterFreq
    gain: input_variables.Gain
    num_samps: '1000'
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {bus_source: true}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}
- name: input_variables
  id: epy_module
  parameters:
    comment: |-
      input_variables:
      Contains all the user-defined variables.
    source_code: |
      # this module will be imported into your flowgraph
      import os
      ToneFreq = 1e6
      SampleRate = 10e6
      CenterFreq = 2490000000
      RxAddr = "addr0=192.168.20.3, addr1=192.168.110.2"
      TxAddr = "addr=192.168.20.3"
      Gain = 60
      NumArrayElements = 4
      NormSpacing = 0.5
      PilotAngle = 45
      SnapshotSize = 2**11
      Samples2FindMax = 2**11
      Samples2Avg = 2**11
      OverlapSize = 2**9
      SkipAhead = 2**13
      NumTargets = 1
      PSpectrumLength = 2**10
      home = os.path.expanduser("~")
      DirectoryConfigFiles = os.path.join(home, "devel/localization_fulbright/config/")
      ConfigFileExt = ".cfg"
      RelativePhaseOffsets = f"measure_X310_TwinRX_relative_phase_offsets_{CenterFreq:.2e}_{SampleRate:.2e}_"
      CorrectedPhaseOffsets = f"measure_X310_TwinRX_corrected_phase_offsets_{CenterFreq:.2e}_{SampleRate:.2e}_"
      AntennaCalibration = f"calibration_lin_array_{CenterFreq:.2e}_{SampleRate:.2e}_" 
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    label1: 'Channel #0: Real'
    label2: 'Channel #0: Imag'
    label3: 'Channel #1: Real'
    label4: 'Channel #1: Imag'
    label5: 'Channel #2: Real'
    label6: 'Channel #2: Imag'
    label7: 'Channel #3: Real'
    label8: 'Channel #3: Imag'
    nconnections: '4'
    size: '256'
    srate: input_variables.SampleRate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.5'
  states: {bus_sink: true}

connections:
- [doa_phase_correct_hier_1, '4', qtgui_time_sink_x_0, '4']
- [doa_tworx_usrp_source_0, '4', doa_phase_correct_hier_1, '4']

metadata:
  file_format: 1
