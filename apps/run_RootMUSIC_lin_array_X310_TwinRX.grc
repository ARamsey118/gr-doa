options:
  parameters:
    generate_options: qt_gui
    id: run_RootMUSIC_lin_array_X310_TwinRX
    output_language: python
  states: {}

blocks:
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)+ vert_horz + input_variables.ConfigFileExt
  states: {}
- name: vert_horz
  id: variable
  parameters:
    value: '"vert"'
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: '1'
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_phase_correct_hier_1
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_qt_compass_0
  id: doa_qt_compass
  parameters:
    arc_bias: '0'
    max_val: '180'
    min_val: '0'
    name: '""'
    step: '10'
    update_time: '0.10'
  states: {}
- name: doa_rootMUSIC_linear_array_0
  id: doa_rootMUSIC_linear_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_tworx_usrp_source_0
  id: doa_tworx_usrp_source
  parameters:
    addresses: '"addr0=192.168.20.3"'
    antenna: RX2
    bus_structure_source: '[[0,],]'
    center_freq: input_variables.CenterFreq
    gain: input_variables.Gain
    num_samps: '1000'
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: input_variables
  id: epy_module
  parameters:
    comment: |-
      input_variables:
      Contains all the user-defined variables.
    source_code: |
      # this module will be imported into your flowgraph
      import os
      ToneFreq = 10000
      SampleRate = 1000000
      CenterFreq = 2450000000
      RxAddr = "addr=192.168.20.3"
      TxAddr = "addr=192.168.20.3"
      Gain = 60
      NumArrayElements = 2
      NormSpacing = 0.5
      PilotAngle = 45
      SnapshotSize = 2**11
      Samples2FindMax = 2**11
      Samples2Avg = 2**11
      OverlapSize = 2**9
      SkipAhead = 2**13
      NumTargets = 1
      PSpectrumLength = 2**10
      home = os.path.expanduser("~")
      DirectoryConfigFiles = os.path.join(home, "devel/localization_fulbright/config/")
      RelativePhaseOffsets = f"measure_X310_TwinRX_relative_phase_offsets_{CenterFreq:.2e}_{SampleRate:.2e}_"
      CorrectedPhaseOffsets = f"measure_X310_TwinRX_corrected_phase_offsets_{CenterFreq:.2e}_{SampleRate:.2e}_"
      AntennaCalibration = f"calibration_lin_array_{CenterFreq:.2e}_{SampleRate:.2e}_"
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Angle of Arrival
    num_tabs: '1'
  states: {}

connections:
- [doa_autocorrelate_0, '0', doa_rootMUSIC_linear_array_0, '0']
- [doa_phase_correct_hier_1, '0', doa_autocorrelate_0, '0']
- [doa_phase_correct_hier_1, '1', doa_autocorrelate_0, '1']
- [doa_rootMUSIC_linear_array_0, '0', doa_qt_compass_0, '0']
- [doa_tworx_usrp_source_0, '0', doa_phase_correct_hier_1, '0']
- [doa_tworx_usrp_source_0, '1', doa_phase_correct_hier_1, '1']

metadata:
  file_format: 1
