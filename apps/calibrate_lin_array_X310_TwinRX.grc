options:
  parameters:
    generate_options: no_gui
    id: calibrate_lin_array_X310_TwinRX
    output_language: python
    run_options: run
  states: {}

blocks:
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)+ vert_horz + input_variables.ConfigFileExt
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)+ vert_horz + input_variables.ConfigFileExt
  states: {}
- name: vert_horz
  id: variable
  parameters:
    value: '"horz"'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: '1'
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_calibrate_lin_array_0
  id: doa_calibrate_lin_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: input_variables.NumArrayElements
    pilot_angle: input_variables.PilotAngle
  states: {}
- name: doa_phase_correct_hier_1
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_save_antenna_calib_0
  id: doa_save_antenna_calib
  parameters:
    config_filename: antenna_calibration_file_name
    num_inputs: input_variables.NumArrayElements
    samples_to_average: input_variables.Samples2Avg
  states: {}
- name: doa_tworx_usrp_source_0
  id: doa_tworx_usrp_source
  parameters:
    addresses: '"addr0=192.168.20.3, addr1=192.168.110.2"'
    antenna: TX/RX
    bus_structure_source: '[[0,],]'
    center_freq: input_variables.CenterFreq
    gain: input_variables.Gain
    num_samps: '1000'
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: import
  id: import
  parameters:
    imports: import os
  states: {}
- name: input_variables
  id: epy_module
  parameters:
    comment: |-
      input_variables:
      Contains all the user-defined variables.
    source_code: |
      # this module will be imported into your flowgraph
      import os
      ToneFreq = 1e6
      SampleRate = 10e6
      CenterFreq = 2.45e9
      RxAddr = "addr=192.168.20.3"
      RxAddr1 = "addr=192.168.110.2"
      TxAddr = "addr=192.168.20.3"
      Gain = 60
      NumArrayElements = 4
      NormSpacing = 0.5
      PilotAngle = 90
      SnapshotSize = 2**11
      Samples2FindMax = 2**11
      Samples2Avg = 2**11
      OverlapSize = 2**9
      SkipAhead = 2**13
      NumTargets = 1
      PSpectrumLength = 2**10
      home = os.path.expanduser("~")
      DirectoryConfigFiles = os.path.join(home, "devel/localization_fulbright/config/")
      ConfigFileExt = ".cfg"
      RelativePhaseOffsets = f"measure_X310_TwinRX_relative_phase_offsets_{CenterFreq:.2e}_{SampleRate:.2e}_"
      CorrectedPhaseOffsets = f"measure_X310_TwinRX_corrected_phase_offsets_{CenterFreq:.2e}_{SampleRate:.2e}_"
      AntennaCalibration = f"calibration_lin_array_{CenterFreq:.2e}_{SampleRate:.2e}_" 
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', doa_save_antenna_calib_0, '0']
- [blocks_complex_to_magphase_0, '1', doa_save_antenna_calib_0, '1']
- [doa_autocorrelate_0, '0', doa_calibrate_lin_array_0, '0']
- [doa_calibrate_lin_array_0, '0', blocks_complex_to_magphase_0, '0']
- [doa_phase_correct_hier_1, '0', doa_autocorrelate_0, '0']
- [doa_phase_correct_hier_1, '1', doa_autocorrelate_0, '1']
- [doa_phase_correct_hier_1, '2', doa_autocorrelate_0, '2']
- [doa_phase_correct_hier_1, '3', doa_autocorrelate_0, '3']
- [doa_tworx_usrp_source_0, '0', doa_phase_correct_hier_1, '0']
- [doa_tworx_usrp_source_0, '1', doa_phase_correct_hier_1, '1']
- [doa_tworx_usrp_source_0, '2', doa_phase_correct_hier_1, '2']
- [doa_tworx_usrp_source_0, '3', doa_phase_correct_hier_1, '3']

metadata:
  file_format: 1
