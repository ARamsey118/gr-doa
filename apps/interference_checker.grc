options:
  parameters:
    generate_options: qt_gui
    id: signal_test
    output_language: python
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 2.49e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    label1: Rx Spectrum
    name: Rx Spectrum
    showports: 'True'
    type: complex
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: 2**13
    srate: samp_rate
    tr_level: '0.003'
    type: complex
    ymax: '0.005'
    ymin: '-0.005'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dc_offs_enb0: '""'
    dev_addr: '"addr=192.168.20.3"'
    dev_args: '""'
    gain0: '60'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
