options:
  parameters:
    generate_options: qt_gui
    id: run_MUSIC_calib_lin_array_simulation
    output_language: python
  states: {}

blocks:
- name: amv0
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv0_true)
  states: {}
- name: amv0_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta0))
  states: {}
- name: amv1
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv1_true)
  states: {}
- name: amv1_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta1))
  states: {}
- name: ant_coeffs
  id: variable
  parameters:
    comment: |-
      These simulated antenna coefficients need 
      to be the same as those used in 
      apps/run_calib_lin_array_simulation.grc
    value: input_variables.AntGains*numpy.exp(1j*input_variables.AntPhases)
  states: {}
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(0.5, numpy.arange(input_variables.NumArrayElements/2, -input_variables.NumArrayElements/2, -1) if (input_variables.NumArrayElements%2==1) else numpy.arange(input_variables.NumArrayElements/2-0.5, -input_variables.NumArrayElements/2-0.5, -1))
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: array_manifold_matrix
  id: variable
  parameters:
    value: numpy.array([amv0, amv1]).transpose()
  states: {}
- name: theta0
  id: variable
  parameters:
    value: numpy.pi*theta0_deg/180
  states: {}
- name: theta0_deg
  id: variable_qtgui_range
  parameters:
    label: AoA
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '180'
    value: '30'
  states: {}
- name: theta1
  id: variable
  parameters:
    value: numpy.pi*theta1_deg/180
  states: {}
- name: theta1_deg
  id: variable_qtgui_range
  parameters:
    label: AoA
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '180'
    value: '123'
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.0005'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: input_variables.ToneFreq1
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: input_variables.ToneFreq2
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: array_manifold_matrix
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: input_variables.NumTargets
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: input_variables.SampleRate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: input_variables.NumTargets
    type: float
  states: {}
- name: doa_MUSIC_lin_array_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_antenna_correction_0
  id: doa_antenna_correction
  parameters:
    config_filename: antenna_calibration_file_name
    num_inputs: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: '1'
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_compass
  id: doa_qt_compass
  parameters:
    arc_bias: '0'
    gui_hint: tab@2
    max_val: '180'
    min_val: '0'
    name: '""'
    step: '10'
    update_time: '0.05'
  states: {}
- name: doa_compass_0
  id: doa_qt_compass
  parameters:
    arc_bias: '0'
    gui_hint: tab@1
    max_val: '180'
    min_val: '0'
    name: '""'
    step: '10'
    update_time: '0.05'
  states: {}
- name: doa_find_local_max_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: input_variables
  id: epy_module
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    source_code: |-
      # Comment here
      import numpy
      SampleRate = 320000
      ToneFreq1 = 10000
      AntPhases = numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])
      DirectoryConfigFiles = "/tmp"
      AntennaCalibration = "calibration_lin_array_simulated.cfg"
      ToneFreq2 = 20000
      NormSpacing = 0.5
      NumTargets = 2
      NumArrayElements = 4
      PSpectrumLength = 2**10
      SnapshotSize = 2**11
      OverlapSize = 2**9
      AntGains = numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929]) 
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: tab@0
    showports: 'True'
    update_time: '0.05'
    vlen: input_variables.PSpectrumLength
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/input_variables.PSpectrumLength
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Pseudo-Spectrum
    label1: Direction of Arrival
    label2: Direction of Arrival
    num_tabs: '3'
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_matrix_xx_0, '0', doa_antenna_correction_0, '0']
- [blocks_multiply_matrix_xx_0, '1', doa_antenna_correction_0, '1']
- [blocks_multiply_matrix_xx_0, '2', doa_antenna_correction_0, '2']
- [blocks_multiply_matrix_xx_0, '3', doa_antenna_correction_0, '3']
- [blocks_throttle_0_0, '0', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_streams_0, '0', doa_compass_0, '0']
- [blocks_vector_to_streams_0, '1', doa_compass, '0']
- [doa_MUSIC_lin_array_0, '0', doa_find_local_max_0, '0']
- [doa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [doa_antenna_correction_0, '0', doa_autocorrelate_0, '0']
- [doa_antenna_correction_0, '1', doa_autocorrelate_0, '1']
- [doa_antenna_correction_0, '2', doa_autocorrelate_0, '2']
- [doa_antenna_correction_0, '3', doa_autocorrelate_0, '3']
- [doa_autocorrelate_0, '0', doa_MUSIC_lin_array_0, '0']
- [doa_find_local_max_0, '0', blocks_null_sink_0, '0']
- [doa_find_local_max_0, '1', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
